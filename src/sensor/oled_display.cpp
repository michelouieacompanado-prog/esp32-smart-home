// Implementation of the SSD1306 OLED display driver.

#include "sensor/oled_display.hpp"
#include "sensor/config.hpp"

#include <cstdio>
#include <cstring>
#include "esp_log.h"
#include "driver/i2c.h"

namespace app::sensor {

namespace {
constexpr const char* kTag = "oled_display";

// Standard 5x7 ASCII font bitmap table (ASCII 32 to 126)
const uint8_t kFont5x7[][5] = {
    {0x00, 0x00, 0x00, 0x00, 0x00}, // 32 ' '
    {0x00, 0x00, 0x5F, 0x00, 0x00}, // 33 '!'
    {0x00, 0x07, 0x00, 0x07, 0x00}, // 34 '"'
    {0x14, 0x7F, 0x14, 0x7F, 0x14}, // 35 '#'
    {0x24, 0x2A, 0x7F, 0x2A, 0x12}, // 36 '$'
    {0x23, 0x13, 0x08, 0x64, 0x62}, // 37 '%'
    {0x36, 0x49, 0x55, 0x22, 0x50}, // 38 '&'
    {0x00, 0x05, 0x03, 0x00, 0x00}, // 39 '''
    {0x00, 0x1C, 0x22, 0x41, 0x00}, // 40 '('
    {0x00, 0x41, 0x22, 0x1C, 0x00}, // 41 ')'
    {0x14, 0x08, 0x3E, 0x08, 0x14}, // 42 '*'
    {0x08, 0x08, 0x3E, 0x08, 0x08}, // 43 '+'
    {0x00, 0x50, 0x30, 0x00, 0x00}, // 44 ','
    {0x08, 0x08, 0x08, 0x08, 0x08}, // 45 '-'
    {0x00, 0x60, 0x60, 0x00, 0x00}, // 46 '.'
    {0x20, 0x10, 0x08, 0x04, 0x02}, // 47 '/'
    {0x3E, 0x51, 0x49, 0x45, 0x3E}, // 48 '0'
    {0x00, 0x42, 0x7F, 0x40, 0x00}, // 49 '1'
    {0x42, 0x61, 0x51, 0x49, 0x46}, // 50 '2'
    {0x21, 0x41, 0x45, 0x4B, 0x31}, // 51 '3'
    {0x18, 0x14, 0x12, 0x7F, 0x10}, // 52 '4'
    {0x27, 0x45, 0x45, 0x45, 0x39}, // 53 '5'
    {0x3C, 0x4A, 0x49, 0x49, 0x30}, // 54 '6'
    {0x01, 0x71, 0x09, 0x05, 0x03}, // 55 '7'
    {0x36, 0x49, 0x49, 0x49, 0x36}, // 56 '8'
    {0x06, 0x49, 0x49, 0x29, 0x1E}, // 57 '9'
    {0x00, 0x36, 0x36, 0x00, 0x00}, // 58 ':'
    {0x00, 0x56, 0x36, 0x00, 0x00}, // 59 ';'
    {0x08, 0x14, 0x22, 0x41, 0x00}, // 60 '<'
    {0x14, 0x14, 0x14, 0x14, 0x14}, // 61 '='
    {0x00, 0x41, 0x22, 0x14, 0x08}, // 62 '>'
    {0x02, 0x01, 0x51, 0x09, 0x06}, // 63 '?'
    {0x32, 0x49, 0x79, 0x41, 0x3E}, // 64 '@'
    {0x7E, 0x11, 0x11, 0x11, 0x7E}, // 65 'A'
    {0x7F, 0x49, 0x49, 0x49, 0x36}, // 66 'B'
    {0x3E, 0x41, 0x41, 0x41, 0x22}, // 67 'C'
    {0x7F, 0x41, 0x41, 0x22, 0x1C}, // 68 'D'
    {0x7F, 0x49, 0x49, 0x49, 0x41}, // 69 'E'
    {0x7F, 0x09, 0x09, 0x09, 0x01}, // 70 'F'
    {0x3E, 0x41, 0x49, 0x49, 0x7A}, // 71 'G'
    {0x7F, 0x08, 0x08, 0x08, 0x7F}, // 72 'H'
    {0x00, 0x41, 0x7F, 0x41, 0x00}, // 73 'I'
    {0x20, 0x40, 0x41, 0x3F, 0x01}, // 74 'J'
    {0x7F, 0x08, 0x14, 0x22, 0x41}, // 75 'K'
    {0x7F, 0x40, 0x40, 0x40, 0x40}, // 76 'L'
    {0x7F, 0x02, 0x04, 0x02, 0x7F}, // 77 'M'
    {0x7F, 0x04, 0x08, 0x10, 0x7F}, // 78 'N'
    {0x3E, 0x41, 0x41, 0x41, 0x3E}, // 79 'O'
    {0x7F, 0x09, 0x09, 0x09, 0x06}, // 80 'P'
    {0x3E, 0x41, 0x51, 0x21, 0x5E}, // 81 'Q'
    {0x7F, 0x09, 0x19, 0x29, 0x46}, // 82 'R'
    {0x46, 0x49, 0x49, 0x49, 0x31}, // 83 'S'
    {0x01, 0x01, 0x7F, 0x01, 0x01}, // 84 'T'
    {0x3F, 0x40, 0x40, 0x40, 0x3F}, // 85 'U'
    {0x1F, 0x20, 0x40, 0x20, 0x1F}, // 86 'V'
    {0x3F, 0x40, 0x38, 0x40, 0x3F}, // 87 'W'
    {0x63, 0x14, 0x08, 0x14, 0x63}, // 88 'X'
    {0x07, 0x08, 0x70, 0x08, 0x07}, // 89 'Y'
    {0x61, 0x51, 0x49, 0x45, 0x43}, // 90 'Z'
    {0x00, 0x7F, 0x41, 0x41, 0x00}, // 91 '['
    {0x02, 0x04, 0x08, 0x10, 0x20}, // 92 '\'
    {0x00, 0x41, 0x41, 0x7F, 0x00}, // 93 ']'
    {0x04, 0x02, 0x01, 0x02, 0x04}, // 94 '^'
    {0x40, 0x40, 0x40, 0x40, 0x40}, // 95 '_'
    {0x00, 0x01, 0x02, 0x04, 0x00}, // 96 '`'
    {0x20, 0x54, 0x54, 0x54, 0x78}, // 97 'a'
    {0x7F, 0x48, 0x44, 0x44, 0x38}, // 98 'b'
    {0x38, 0x44, 0x44, 0x44, 0x20}, // 99 'c'
    {0x38, 0x44, 0x44, 0x48, 0x7F}, // 100 'd'
    {0x38, 0x54, 0x54, 0x54, 0x18}, // 101 'e'
    {0x08, 0x7E, 0x09, 0x01, 0x02}, // 102 'f'
    {0x0C, 0x52, 0x52, 0x52, 0x3E}, // 103 'g'
    {0x7F, 0x08, 0x04, 0x04, 0x78}, // 104 'h'
    {0x00, 0x44, 0x7D, 0x40, 0x00}, // 105 'i'
    {0x20, 0x40, 0x44, 0x3D, 0x00}, // 106 'j'
    {0x7F, 0x10, 0x28, 0x44, 0x00}, // 107 'k'
    {0x00, 0x41, 0x7F, 0x40, 0x00}, // 108 'l'
    {0x7C, 0x04, 0x18, 0x04, 0x78}, // 109 'm'
    {0x7C, 0x08, 0x04, 0x04, 0x78}, // 110 'n'
    {0x38, 0x44, 0x44, 0x44, 0x38}, // 111 'o'
    {0x7C, 0x14, 0x14, 0x14, 0x08}, // 112 'p'
    {0x08, 0x14, 0x14, 0x18, 0x7C}, // 113 'q'
    {0x7C, 0x08, 0x04, 0x04, 0x08}, // 114 'r'
    {0x48, 0x54, 0x54, 0x54, 0x20}, // 115 's'
    {0x04, 0x3F, 0x44, 0x40, 0x20}, // 116 't'
    {0x3C, 0x40, 0x40, 0x20, 0x7C}, // 117 'u'
    {0x1C, 0x20, 0x40, 0x20, 0x1C}, // 118 'v'
    {0x3C, 0x40, 0x30, 0x40, 0x3C}, // 119 'w'
    {0x44, 0x28, 0x10, 0x28, 0x44}, // 120 'x'
    {0x0C, 0x50, 0x50, 0x50, 0x3C}, // 121 'y'
    {0x44, 0x64, 0x54, 0x4C, 0x44}, // 122 'z'
    {0x00, 0x08, 0x36, 0x41, 0x00}, // 123 '{'
    {0x00, 0x00, 0x7F, 0x00, 0x00}, // 124 '|'
    {0x00, 0x41, 0x36, 0x08, 0x00}, // 125 '}'
    {0x08, 0x08, 0x2A, 0x1C, 0x08}  // 126 '~'
};

} // namespace

OledDisplay::OledDisplay()
    : m_port(kI2cPort),
      m_initialized(false) {
    std::memset(m_buffer, 0, sizeof(m_buffer));
}

OledDisplay::~OledDisplay() {
}

esp_err_t OledDisplay::sendCommand(uint8_t command) {
    uint8_t buffer[2] = {0x00, command};
    return i2c_master_write_to_device(m_port, kSsd1306I2cAddress, buffer, sizeof(buffer), pdMS_TO_TICKS(100));
}

esp_err_t OledDisplay::sendData(const uint8_t* data, size_t length) {
    i2c_cmd_handle_t cmd = i2c_cmd_link_create();
    i2c_master_start(cmd);
    i2c_master_write_byte(cmd, (kSsd1306I2cAddress << 1) | I2C_MASTER_WRITE, true);
    i2c_master_write_byte(cmd, 0x40, true);
    i2c_master_write(cmd, data, length, true);
    i2c_master_stop(cmd);
    esp_err_t err = i2c_master_cmd_begin(m_port, cmd, pdMS_TO_TICKS(200));
    i2c_cmd_link_delete(cmd);
    return err;
}

esp_err_t OledDisplay::init(i2c_port_t port) {
    m_port = port;

    // Standard SSD1306 initialization sequence
    const uint8_t initCommands[] = {
        0xAE,       // Display OFF
        0xD5, 0x80, // Set display clock divide ratio/oscillator frequency
        0xA8, 0x3F, // Set multiplex ratio (64 lines)
        0xD3, 0x00, // Set display offset to 0
        0x40,       // Set display start line to 0
        0x8D, 0x14, // Enable charge pump
        0x20, 0x00, // Set Memory Addressing Mode (Horizontal)
        0xA1,       // Set Segment Re-map (A0/A1)
        0xC8,       // Set COM Output Scan Direction (C0/C8)
        0xDA, 0x12, // Set COM Pins hardware configuration
        0x81, 0x7F, // Set Contrast Control
        0xD9, 0xF1, // Set Pre-charge Period
        0xDB, 0x40, // Set VCOMH Deselect Level
        0xA4,       // Entire Display ON (Resume to RAM content)
        0xA6,       // Set Normal Display (A6 normal, A7 inverse)
        0xAF        // Display ON
    };

    for (size_t i = 0; i < sizeof(initCommands); ++i) {
        esp_err_t err = sendCommand(initCommands[i]);
        if (err != ESP_OK) {
            ESP_LOGE(kTag, "Failed to send SSD1306 init cmd 0x%02X: %s", initCommands[i], esp_err_to_name(err));
            return err;
        }
    }

    m_initialized = true;
    clear();
    ESP_LOGI(kTag, "SSD1306 OLED initialized successfully at address 0x%02X", kSsd1306I2cAddress);
    return ESP_OK;
}

void OledDisplay::clear() {
    std::memset(m_buffer, 0, sizeof(m_buffer));
    sendCommand(0x21); // Set column address
    sendCommand(0x00);
    sendCommand(127);
    sendCommand(0x22); // Set page address
    sendCommand(0x00);
    sendCommand(0x07);
    sendData(m_buffer, sizeof(m_buffer));
}

void OledDisplay::drawChar(uint8_t x, uint8_t page, char c) {
    if (page >= 8 || x > (128 - 6)) {
        return;
    }
    if (c < 32 || c > 126) {
        c = ' ';
    }
    const uint8_t* glyph = kFont5x7[c - 32];
    for (uint8_t i = 0; i < 5; ++i) {
        m_buffer[page * 128 + x + i] = glyph[i];
    }
    m_buffer[page * 128 + x + 5] = 0x00;
}

void OledDisplay::drawString(uint8_t x, uint8_t page, const char* str) {
    if (str == nullptr) {
        return;
    }
    while (*str != '\0' && x <= (128 - 6)) {
        drawChar(x, page, *str);
        x += 6;
        str++;
    }
}

void OledDisplay::update(float temperature,
                         uint8_t lightIntensity,
                         bool valid,
                         bool wifiConnected,
                         bool mqttConnected,
                         const char* timeString) {
    if (!m_initialized) {
        return;
    }

    std::memset(m_buffer, 0, sizeof(m_buffer));

    // Page 0: Header & Network Status
    char statusBuf[24];
    std::snprintf(statusBuf, sizeof(statusBuf), "W:%s M:%s",
                  wifiConnected ? "OK" : "--",
                  mqttConnected ? "OK" : "--");
    drawString(0, 0, statusBuf);

    // Page 1: Divider line
    for (uint8_t col = 0; col < 128; ++col) {
        m_buffer[1 * 128 + col] = 0x01;
    }

    // Page 2 & 3: Time
    char timeBuf[24];
    std::snprintf(timeBuf, sizeof(timeBuf), "Time: %s", (timeString != nullptr) ? timeString : "--:--:--");
    drawString(0, 2, timeBuf);

    // Page 4: Temperature
    char tempBuf[24];
    if (valid) {
        std::snprintf(tempBuf, sizeof(tempBuf), "Temp : %.1f C", temperature);
    } else {
        std::snprintf(tempBuf, sizeof(tempBuf), "Temp : --.- C");
    }
    drawString(0, 4, tempBuf);

    // Page 6: Light intensity
    char lightBuf[24];
    if (valid) {
        std::snprintf(lightBuf, sizeof(lightBuf), "Light: %u %%", lightIntensity);
    } else {
        std::snprintf(lightBuf, sizeof(lightBuf), "Light: -- %%");
    }
    drawString(0, 6, lightBuf);

    // Flush buffer to display
    sendCommand(0x21); // Set column address
    sendCommand(0x00);
    sendCommand(127);
    sendCommand(0x22); // Set page address
    sendCommand(0x00);
    sendCommand(0x07);
    sendData(m_buffer, sizeof(m_buffer));
}

} // namespace app::sensor
